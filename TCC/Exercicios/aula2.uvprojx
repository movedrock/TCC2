# Keil uVision project aula2.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC1343FBD48 NXP
  pack: Keil.LPC1300_DFP.1.0.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: aula2
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: main.s
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
